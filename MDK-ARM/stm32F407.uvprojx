# Keil uVision project stm32F407.uvprojx, settings and files
target stm32F407 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: stm32F407 +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe  --bin -o stm32F407.bin stm32F407\stm32F407.axf
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c misc: --C99
  c include: ../Inc;                    ../Drivers/STM32F4xx_HAL_Driver/Inc;                    ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;                    ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;                    ../Drivers/CMSIS/Include;                    ../Middlewares/Third_Party/LwIP/src/include;                    ../Middlewares/Third_Party/LwIP/system;                    ../Middlewares/Third_Party/LwIP/src/include/lwip;                    ../Middlewares/Third_Party/LwIP/src/include/lwip/apps;                    ../Middlewares/Third_Party/LwIP/src/include/lwip/priv;                    ../Middlewares/Third_Party/LwIP/src/include/lwip/prot;                    ../Middlewares/Third_Party/LwIP/src/include/netif;                    ../Middlewares/Third_Party/LwIP/src/include/netif/ppp;                    ../Middlewares/Third_Party/LwIP/src/include/posix;                    ../Middlewares/Third_Party/LwIP/src/include/posix/sys;                    ../Middlewares/Third_Party/LwIP/system/arch;                    ..\Middlewares\Third_Party\Modbus\modbus\include;                    ..\Middlewares\Third_Party\Modbus\port;                    ..\Middlewares\Third_Party\Modbus\modbus\functions;                    ..\Middlewares\Third_Party\Modbus\modbus\tcp;                    ..\Middlewares\Third_Party\Modbus\modbus\rtu;                    ..\Middlewares\Third_Party\Modbus\modbus\ascii;                    ..\Middlewares\Third_Party\Modbus\modbus;                    ..\Middlewares\Third_Party\W25Q128
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0x70000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_rcc.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_dma.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal.c stm32f4xx_hal_pwr.c stm32f4xx_hal_eth.c stm32f4xx_hal_uart.c stm32f4xx_hal_spi.c stm32f4xx_hal_wwdg.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Middlewares/LwIP
    ../Middlewares/Third_Party/LwIP/src/api/: api_msg.c netifapi.c netbuf.c netdb.c sockets.c api_lib.c tcpip.c err.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv6/: ip6_addr.c icmp6.c dhcp6.c inet6.c ip6_frag.c mld6.c nd6.c ip6.c ethip6.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv4/: dhcp.c icmp.c ip4.c ip4_addr.c autoip.c ip4_frag.c igmp.c etharp.c
    ../Middlewares/Third_Party/LwIP/src/netif/ppp/: mppe.c ccp.c chap-new.c upap.c pppapi.c magic.c eui64.c chap-md5.c ppp.c multilink.c ipcp.c demand.c pppcrypt.c auth.c fsm.c vj.c chap_ms.c pppol2tp.c pppos.c lcp.c ipv6cp.c utils.c eap.c ecp.c pppoe.c
    ../Middlewares/Third_Party/LwIP/src/core/: inet_chksum.c dns.c mem.c init.c tcp_in.c tcp.c ip.c tcp_out.c raw.c stats.c def.c memp.c timeouts.c udp.c netif.c sys.c pbuf.c
    ../Middlewares/Third_Party/LwIP/src/netif/: slipif.c ethernet.c lowpan6.c
    ../Middlewares/Third_Party/LwIP/src/apps/tftp/: tftp_server.c
  group Middlewares/Modbus
    ../Middlewares/Third_Party/Modbus/modbus/: mb.c
    ../Middlewares/Third_Party/Modbus/modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
    ../Middlewares/Third_Party/Modbus/modbus/rtu/: mbcrc.c
    ../Middlewares/Third_Party/Modbus/modbus/tcp/: mbtcp.c
    ../Middlewares/Third_Party/Modbus/port/: portevent.c portother.c porttcp.c
  group Middlewares/W25Q128
    ../Middlewares/Third_Party/W25Q128/: w25qxx.c
  group Application/User
    ../Src/: ethernetif.c stm32f4xx_it.c main.c stm32f4xx_hal_msp.c lwip.c platform.c flash_if.c
